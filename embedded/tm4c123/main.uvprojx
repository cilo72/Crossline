# Keil uVision project main.uvprojx, settings and files
target Slave (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: arm6 PART_TM4C129DNCPDT DEBUG __USE_C99_MATH CROSS_EMBEDDED
  c include: .\TivaWare_C_Series-2.2.0.295\driverlib;.\TivaWare_C_Series-2.2.0.295;..\..\..\crossline
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Main
    ./: Startup.s main.c
    ../../: crossline.c
  group Libraries
    ./TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
